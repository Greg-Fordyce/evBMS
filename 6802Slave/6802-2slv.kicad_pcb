# Repository Greg-Fordyce/evBMS

File readme.txt:

An open source battery management system for electric vehicles using lithium cells.

We make no claims about safety/effectiveness/reliability of this system.
It's just one of the many possible solutions now available for the management of EV batteries, and the standard disclaimer below applies.

This BMS carries no warranty or guarantee of any kind! It's used at your own risk, and I make no claims as to suitability for a particular function. Prospective users must evaluate the system before using it, and no liability will be entertained by anyone in any shape or form whatsoever.
The modules and software have been produced at low cost for the benefit of the EV & electronic community. The software is available free via the internet. Users may modify or adapt the system as they see fit. If you are not fully competent to work on potentially lethal battery systems and high voltages, then do not experiment with or use this system. Be aware that vehicle modifications can lead to invalidated insurance and warranty issues. You the end user remain fully liable for any modifications made to your vehicle.
The following licensces cover all aspects of this project. 
Hardware designs are licensed under the  TAPR Open Hardware License - http://www.tapr.org/ohl.html
All software/code is covered by the GPLv3 - http://www.gnu.org/licenses/gpl-3.0.html
Documentation is under the Creative Commons Attribution-ShareAlike 3.0 Unported - http://creativecommons.org/licenses/by-sa/3.0/
A useful list of other available BMS designs for your consideration is here
http://liionbms.com/php/bms_options.php

This is a open source battery management system for electric vehicles. The project started June 2008 and the main development work can be found on the Battery Vehicle Society forums here; http://www.batteryvehiclesociety.org.uk/forums/viewforum.php?f=53

The first generation system consists of slave boards, one for each cell (the latest designs incorporate multiple slaves on a single pcb) and a master board. The slaves report individual cell voltages to the master and also have a small load resistor for balancing cells during charging. The master controls charging and discharging, making sure all cells don't get over or undercharged. In addition the master also reads current through the pack, vehicle speed and pack temperatures and can calculate state of charge, remaining range, watt hours per mile, etc.

The second generation system has multiple slave boards that can do from 4 to 12 cells each and should  be suitable for all lithium battery chemstries along with Nicad and Nimh. Each slave board consists of a LTC6802-2 for measuring cell voltages and temperatures, a 16F1825 pic microcontroller that acts as a interface between the 6802 and master and a TTL-RS232 level converter for reliable comunications in a electric vehicle (while audibly quiet, EVs can be very noisy electrically. The Master used at the moment is based on a Maximite (http://geoffg.net/maximite.html) but the slaves are designed to be very simple to use, only 3 commands required, report cell voltage, report cell temperature and report current, so developing other master options should be fairly straight forward.
Project status as of March 2013. Prototype slaves are being tested/working in a electric vehicle with some simple code. I hope to have slave boards availible around May 2013 for anyone interested in this project. Pcb design is being done in Kicad and slave software is in PicBasic Pro.
Greg

## KiCad design 6802Slave/6802-2slv.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C17, C19, C20: 100nf
C14, C15, C16, C18, C21, C22, C23, C24, C25: 1uf
D1: BI_LED
D2: 1N4148
J1: DB15
J2: USB B conn.
J3: USB A connector
J4: ICSP
P1: CONN_1
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 100R
R13: 20R
R14, R15, R29, R30: 200K
R16: 4K7
R17: 1K
R18: 680R
R19, R20, R22, R23: 845R
R21, R25, R26, R27, R28: 330R
R24: 10K
U1: LTC6802-2
U2: TCLT1009
U3: ACPL-W61L
U4: ACPL-K64L
U5: PIC16F1825
U6: MAX232

Connections:
GND: C19.2, C20.1, C23.2, C25.1, D1.2 (K), J2.4, J3.4, J4.3, U2.2 (K), U3.4 (GND), U5.14 (VSS), U6.15 (GND)
GNDPWR: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, J1.7, P1.1, U1.26 (V-), U1.27 (NC), U1.37 (A0), U1.38 (A1), U1.39 (A2), U1.40 (A3), U2.3 (E), U4.5 (GND)
unnamed: R16.1, U1.44 (CSBI), U2.4 (C)
unnamed: C13.1, R13.2, U1.1 (V+)
unnamed: C6.1, R6.2, U1.14 (C6)
unnamed: C22.2, U6.1 (C1+)
unnamed: C22.1, U6.3 (C1-)
unnamed: C24.2, U6.4 (C2+)
unnamed: C24.1, U6.5 (C2-)
unnamed: C25.2, U6.6 (V-)
unnamed: J1.1, R12.1, R13.1
unnamed: C8.1, R8.2, U1.10 (C8)
unnamed: C12.1, R12.2, U1.2 (C12)
unnamed: C11.1, R11.2, U1.4 (C11)
unnamed: C2.1, R2.2, U1.22 (C2)
unnamed: C1.1, R1.2, U1.24 (C1)
unnamed: C10.1, R10.2, U1.6 (C10)
unnamed: C9.1, R9.2, U1.8 (C9)
unnamed: C5.1, R5.2, U1.16 (C5)
unnamed: J1.4, R6.1
unnamed: C4.1, R4.2, U1.18 (C4)
unnamed: J1.11 (P111), R7.1
unnamed: C7.1, R7.2, U1.12 (C7)
unnamed: J1.14, R1.1
unnamed: J1.6, R2.1
unnamed: J1.13, R3.1
unnamed: J1.5, R4.1
unnamed: D2.2 (K), J2.3, J3.3
unnamed: J1.2, R10.1
unnamed: J1.10, R9.1
unnamed: J1.3, R8.1
unnamed: D1.1 (A1), R25.1
unnamed: D1.3 (A2), R26.1
unnamed: J1.9, R11.1
unnamed: J3.2, U6.14 (T1OUT)
unnamed: J4.4, R27.2
unnamed: R27.1, U5.13 (ICSPDAT)
unnamed: R28.1, U5.12 (ICSPCLK)
unnamed: J4.5, R28.2
unnamed: J1.12, R5.1
unnamed: U5.6 (RC4/TX), U6.10 (T2IN)
unnamed: U5.7 (RC3), U6.11 (T1IN)
unnamed: U5.5 (RC5/RX), U6.12 (R1OUT)
unnamed: R23.2, U5.10 (SCK/RC0)
unnamed: D2.1 (A), U6.7 (T2OUT)
unnamed: J2.2, U6.13 (R1IN)
unnamed: C21.1, U6.2 (V+)
unnamed: R21.1, U5.11 (SS/RA2)
unnamed: R26.2, U5.3 (RA4)
unnamed: R25.2, U5.2 (RA5)
unnamed: J4.1, R24.1, U5.4 (RA3/MCLR)
unnamed: R18.2, U1.43 (SDO)
unnamed: R17.1, U3.1 (A)
unnamed: R18.1, U3.3 (K)
unnamed: U1.41 (SCKI), U4.7 (Vo1)
unnamed: U1.42 (SDI), U4.6 (Vo2)
unnamed: U3.5 (Vo), U5.9 (SDI/RC1)
unnamed: R22.2, U4.1 (A1)
unnamed: R19.2, U4.4 (A2)
unnamed: R20.1, U4.3 (K2)
unnamed: R20.2, U5.8 (SDO/RC2)
unnamed: R23.1, U4.2 (K1)
unnamed: R21.2, U2.1 (A)
unnamed: C14.1, J1.15, R14.2, R29.2, U1.28 (Vtemp1)
unnamed: C18.1, R14.1, R15.1, R29.1, R30.1, U1.30 (Vref)
unnamed: C3.1, R3.2, U1.20 (C3)
unnamed: C15.1, J1.8, R15.2, R30.2, U1.29 (Vtemp2)
unnamed: C19.1, C20.2, C21.2, C23.1, J2.1, J3.1, J4.2, R19.1, R22.1, R24.2, U3.6 (Vdd), U5.1 (VDD), U6.16 (VCC)
unnamed: C16.2, C17.1, R16.2, R17.2, U1.31 (Vreg), U1.32 (TOS), U1.33 (MMB), U4.8 (Vdd)
unnamed: J2.5, J2.6, J3.5, J3.6

Notes on the sheet:
Input filters
Connect to 100K thermistors (tempco -4%/C) or use diodes (2.2mv/C)
Standard USB connectors used for bus in and out connections. This allows the use of off the shelf cables for master-slave and slave-slave connections. NOTE: this is not a USB compatible connection. MAX232 used to shift ttl bus signals to RS232 levels. D3 prevents U7 from pulling master bus negative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
LTC6802 powered from cells. Allowable range 10 - 60 volts 4 - 12 cells.
Bus In
Bus Out
Connect 2nd wire from temperature sensors to Cell 1 negative in battery box.
Slave bus in
Slave bus out
Master bus out
For temperature sensor 1 on J1-pin15, omit R29 when using diodes. If using thermistor, add R29 to circuit. For temperature sensor 2 on J1-pin8, omit R30 when using diodes. If using thermistor, add R30 to circuit.

Board: 2 copper layers, 68 parts (0 on the bottom side), 70 nets.

## Commit log

2013-02-28 Added HEX file
2013-02-28 Added new command to slave
    Command 200 starts A/D and reports cell voltages with a single command.
2013-03-01 tidy up code
    Command 200 not working yet
2013-03-02 Added command 200
    Command 200 is a single command for reading cell voltages. Any slave
    recieving will run a routine to start A/D conversions on all slaves and
    then tell all slaves to report cell voltages.
2013-03-02 Colour Maximite master code
    Initial version of master code. SCREEN.BMP is required background image.
2013-03-03 Added simple charge relay routine
    Simple routine to control charger relay on pin 11 of MM
2013-03-04 A start with some current sensor code
    Copied in some code from old master software as a starting point. Code
    compiles but won't run until configuration settings are fixed.
2013-03-05 Set ADC configuration registers
    Compiles O.K. but untested.
2013-03-06 Code runs on slave
2013-03-08 Working current sensor routine
    Master and slave code updated with simple routine for reading current
    sensor. Raw adc from slave is output to master which then converts to
    amp reading
2013-03-08 Initial temperature code
    Compiles o.k. but untested
2013-03-09 Working temp sensor routine
    Also added current sensor detect so slave only reads optional current
    sensor if connected.
2013-03-10 Added readme
2013-03-13 Master code updated
    Added ability to scroll through cell bar graphs and highlight individual
    cell readings. Fixed Inkey$ routine and reorganized code with
    subroutines.
2013-03-14 added copyright notice
2013-03-14 Copyright notice
2013-03-18 Added Kicad project file
2013-03-18 update kicad lib pointer
2013-03-18 started pcb layout
2013-03-23 fixed schematic comments
2013-03-24 layout work
2013-03-24 more pcb layout
2013-03-24 pcb layout nearly finished
2013-04-01 Initial board outline
2013-04-06 Updated board outline
    Outline to fit Hammond 1593N
2013-04-10 More pcb updates
2013-04-17 Generated gerbers
    Also cleaned up top silkscreen
2013-07-04 Changed cell voltage routine
    Still has some bugs to squash.

Notices in the files:
6802Slave/6802-2slv.kicad_pcb:
Licensed under the TAPR Open Hardware License (www.tapr.org/OHL)
